/dts-v1/;
/ {
    #address-cells = <2>; #size-cells = <1>;
    reserved-memory { #address-cells = <2>; #size-cells = <1>; ranges;
        scratch@21000000 { reg = <0 0x21000000 0x10000>; no-map; };
        @EXTRA_RESERVED@
    };
    openamp-address-space { status = "okay"; };
    rp1_firmware: rp1_firmware { mboxes = <&rp1_mbox 0>; };
    pcie2: pcie { };
    leds { led_pwr: led-pwr { gpios = <&rp1_gpio 44 1>; }; };
    cam0_reg: cam0_reg { gpio = <&rp1_gpio 34 0>; };
    soc-gpio { soc22: grp22 { pins = "gpio22"; }; };
    soc-user { pinctrl-0 = <&soc22>; };
    // Bus and interrupt cells as on the captured CM5 board DTB: RP1 is its own interrupt
    // controller (MSI-X vectors, two cells).
    rp1: rp1 { compatible = "simple-bus"; #address-cells = <2>; #size-cells = <2>;
        #interrupt-cells = <2>; interrupt-controller; interrupt-parent = <&rp1>;
        ranges = <0xc0 0x40000000 0x0 0x0 0x0 0x410000>;
        rp1_clocks: clocks { status = "okay"; };
        rp1_mbox: mailbox@8000 { #mbox-cells = <1>; };
        sram: sram@400000 { #address-cells = <1>; #size-cells = <1>;
            rp1_fw_shmem: shmem@ff00 { reg = <0xff00 0x100>; };
        };
        rp1_uart1: serial@34000 { status = "disabled"; };
        rp1_uart2: serial@38000 { status = "disabled"; };
        rp1_uart3: serial@3c000 { status = "disabled"; };
        rp1_uart4: serial@40000 { status = "disabled"; };
        rp1_uart5: serial@44000 { status = "disabled"; };
        rp1_adc: adc { }; rp1_eth: ethernet { }; rp1_dma: dma { }; rp1_pio: pio { };
        rp1_usb0: usb0 { }; rp1_usb1: usb1 { };
        rp1_pwm0: pwm0 { }; rp1_pwm1: pwm1 { }; rp1_audio_out: audio-out { };
        rp1_i2s0: i2s0 { }; rp1_i2s1: i2s1 { }; rp1_i2s2: i2s2 { };
        rp1_i2c0: i2c@70000 { }; rp1_i2c1: i2c@74000 { status = "disabled"; };
        rp1_i2c2: i2c@78000 { }; rp1_i2c3: i2c@7c000 { }; rp1_i2c4: i2c@80000 { };
        rp1_i2c5: i2c@84000 { }; rp1_i2c6: i2c@88000 { };
        rp1_spi0: spi0 { }; rp1_spi1: spi1 { }; rp1_spi2: spi2 { }; rp1_spi3: spi3 { };
        rp1_spi4: spi4 { }; rp1_spi5: spi5 { }; rp1_spi6: spi6 { }; rp1_spi7: spi7 { };
        rp1_spi8: spi8 { };
        rp1_gpio: gpio@d0000 { #gpio-cells = <2>;
            micclk1_hog { gpio-hog; gpios = <46 0>; output-high; };
            uart0_14_15: rp1_uart0_14_15 {
                tx { function = "uart0"; pins = "gpio14"; };
                rx { function = "uart0"; pins = "gpio15"; };
            };
            gpio22: rp1_gpio22 { function = "gpio"; pins = "gpio22"; };
            gpio4: rp1_gpio4 { function = "gpio"; pins = "gpio4"; };
        };
        rp1_uart0: serial@30000 { pinctrl-0 = <&uart0_14_15>; status = "okay"; };
        user4 { pinctrl-0 = <&gpio4>; };
        @EXTRA_RP1@
    };
};
